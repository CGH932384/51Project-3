# Keil uVision project 3.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App\24c02;.\App\iic;.\App\key;.\App\smg;.\Public;.\App\ds18b20;.\App\beep;.\App\time;.\App\lcd1602
  group User
    ./User/: main.c
  group App
    ./App/key/: key.c
    ./App/beep/: beep.c
    ./App/time/: time.c
    ./App/lcd1602/: lcd1602.c
    ./: time1.c
  group Public
    ./Public/: public.c
